# IAR project binary_counter.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMA3B1KK-KBR AmbiqMicro AMA3B1KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_PART_APOLLO3; AM_PACKAGE_BGA
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\bsp; ..\..\..\..\..\mcu\apollo3; ..\..\..\..\..\CMSIS\ARM\Include; ..\src; ..\..\..\..\..\devices; ..\..\..\..\..; ..\..\..\..\..\utils; ..\..\..\..\..\CMSIS\AmbiqMicro\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: binary_counter.bin
  ILINK.IlinkOutputFile: binary_counter.out
  ILINK.IlinkIcfFile: binary_counter.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\mcu\apollo3\hal\iar\bin\libam_hal.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; AM_PART_APOLLO3; AM_PACKAGE_BGA
  group (top)
    ../src/: binary_counter.c
    ../../../../../devices/: am_devices_led.c
    ../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
    ./: startup_iar.c
