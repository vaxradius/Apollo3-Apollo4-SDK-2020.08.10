# Keil uVision project ble_firmaware_update.uvprojx, settings and files
target ble_firmaware_update (ARM-ADS)
  device: AMAPH1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00000000,0x100000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: ble_firmaware_update
  AfterMake: fromelf --bin --output bin\ble_firmaware_update.bin bin\ble_firmaware_update.axf
  AfterMake: fromelf -cedrst --output bin\ble_firmaware_update.txt bin\ble_firmaware_update.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: SBL_ENABLE AM_PACKAGE_BGA AM_PART_APOLLO4 keil
  c include: ../../../../../../third_party/cordio/ble-host/sources/hci/ambiq/cooper;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../../mcu/apollo4;../../../../../../mcu/apollo4/hal;../../../../bsp;../../../../../../devices;../../../../../../utils;../src;../../../../../..;../../../../../../CMSIS/ARM/Include
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4/hal/mcu/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group src
    ../src/: am_resources.c ble_firmware_update.c
  group devices
    ../../../../../../devices/: am_devices_cooper.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_stdio.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../../bsp/keil/bin/: libam_bsp.lib
    ../../../../../../mcu/apollo4/hal/mcu/keil/bin/: libam_hal.lib
