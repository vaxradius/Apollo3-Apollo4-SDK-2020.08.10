# IAR project nemagfx_grad.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAPH1KK-KBR AmbiqMicro AMAPH1KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK; ENABLE_SPI4; BAREMETAL; AM_PART_APOLLO4; USE_TSI_MALLOC; LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib; PLATFORM=apollo4_nemagfx; AM_PACKAGE_BGA
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\src; ..\..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\..\devices; ..\..\..\..\..\..\mcu\apollo4\hal; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\NemaDC; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\NemaGFX; ..\..\..\..\..\..\third_party\ThinkSi\config\apollo4_nemagfx; ..\..\..\..\..\..\mcu\apollo4; ..\..\..\..\bsp; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\common; ..\..\..\..\..\..\utils; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\NemaDC; ..\..\..\..\..\..; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\common\mem; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\NemaGFX
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: nemagfx_grad.bin
  ILINK.IlinkOutputFile: nemagfx_grad.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\third_party\ThinkSi\config\apollo4_nemagfx\iar\bin\lib_nema_apollo4_nemagfx.a; ..\..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\..\mcu\apollo4\hal\mcu\iar\bin\libam_hal.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK; ENABLE_SPI4; BAREMETAL; AM_PART_APOLLO4; USE_TSI_MALLOC; LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib; PLATFORM=apollo4_nemagfx; AM_PACKAGE_BGA
  group (top)
    ../src/: am_resources.c main.c nemagfx_grad.c
    ../../../../../../third_party/ThinkSi/config/apollo4_nemagfx/: nema_dc_hal.c nema_event.c nema_hal.c nema_utils.c
    ../../../../../../devices/: am_devices_nemadc_rm67162.c
    ../../../../../../utils/: am_util_delay.c am_util_stdio.c
    ./: startup_iar.c
