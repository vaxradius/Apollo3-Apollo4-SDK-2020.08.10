# IAR project hello_world.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAPH1KK-KBR AmbiqMicro AMAPH1KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_PART_APOLLO4; AM_PACKAGE_BGA
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\src; ..\..\..\..\..\..\utils; ..\..\..\..\..\..\mcu\apollo4; ..\..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\..; ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\bsp; ..\..\..\..\..\..\devices
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: hello_world.bin
  ILINK.IlinkOutputFile: hello_world.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\mcu\apollo4\hal\mcu\iar\bin\libam_hal.a; ..\..\..\..\bsp\iar\bin\libam_bsp.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; AM_PART_APOLLO4; AM_PACKAGE_BGA
  group (top)
    ../src/: am_resources.c hello_world.c
    ../../../../../../utils/: am_util_delay.c am_util_id.c am_util_stdio.c
    ./: startup_iar.c
